# Keil uVision project mcx_vision_board.uvprojx, settings and files
target mcx_vision_board (6220000::V6.22::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.17.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: mcx_vision_board
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MCUXPRESSO_SDK,SD_ENABLED,TF_LITE_STATIC_MEMORY,SDK_DEBUGCONSOLE=1,__FPU_PRESENT=1,__USE_CMSIS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb  -fshort-enums
  c include: ..\user;..\..\libraries\board;..\..\libraries\zf_drivers;..\..\libraries\zf_devices;..\..\libraries\components\sdmmc\host;..\..\libraries\components\sdmmc\inc;..\..\libraries\components\sdmmc\osa;..\..\libraries\components\sdmmc\sd;..\..\libraries\components\sdmmc\src;..\..\libraries\components\eiq\tensorflow-lite;..\..\libraries\components\eiq\tensorflow-lite\tensorflow\lite\micro\kernels\neutron;..\..\libraries\components\eiq\tensorflow-lite\third_party\flatbuffers\include;..\..\libraries\components\eiq\tensorflow-lite\third_party\gemmlowp;..\..\libraries\components\eiq\tensorflow-lite\third_party\neutron\common\include;..\..\libraries\components\eiq\tensorflow-lite\third_party\neutron\driver\include;..\..\libraries\components\eiq\tensorflow-lite\third_party\ruy;..\..\libraries\components\eiq\tensorflow-lite\model;..\..\libraries\components\eiq\tensorflow-lite\tensorflow\lite\micro\kernels;..\..\libraries\components\eiq\tensorflow-lite\tensorflow\lite\micro;..\..\libraries\sdk_drivers;..\..\libraries\CMSIS;..\..\libraries\CMSIS\Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm include: ..\..\libraries\components\eiq\tensorflow-lite\model;..\..\libraries\sdk_drivers
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --keep=*(EZH_CODE)
  group user
    ../user/: color_tracer.c color_tracer.h main.cpp smartcar_used19.tflite zf_model_process.cpp zf_model_process.h
  group doc
    ../../libraries/doc/: version.txt
  group board
    ../../libraries/board/: board.c board.h clock_config.c clock_config.h sdmmc_config.c sdmmc_config.h zf_board_init.c zf_board_init.h
  group zf_drivers
    ../../libraries/zf_drivers/: zf_common_font.c zf_common_font.h zf_common_headfile.h zf_common_typedef.h zf_driver_delay.c zf_driver_delay.h zf_driver_ezh.h zf_driver_ezh.lib zf_driver_gpio.c zf_driver_gpio.h zf_driver_sd.c zf_driver_sd.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_uart.c zf_driver_uart.h
  group zf_devices
    ../../libraries/zf_devices/: zf_device_config.h zf_device_config.lib zf_device_ips200.c zf_device_ips200.h zf_device_scc8660.c zf_device_scc8660.h
  group sdk_drivers
    ../../libraries/sdk_drivers/: fsl_adapter_gpio.c fsl_adapter_gpio.h fsl_adapter_lpspi.c fsl_adapter_lpuart.c fsl_adapter_spi.h fsl_adapter_uart.h fsl_assert.c fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_component_generic_list.c fsl_component_generic_list.h fsl_ctimer.c fsl_ctimer.h fsl_debug_console.c fsl_debug_console.h fsl_edma.c fsl_edma.h fsl_edma_core.h fsl_edma_soc.c fsl_edma_soc.h fsl_flexio.c fsl_flexio.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_lpflexcomm.c fsl_lpflexcomm.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_port.h fsl_reset.c fsl_reset.h fsl_smartdma.c fsl_smartdma.h fsl_smartdma_mcxn.c fsl_smartdma_mcxn.h fsl_smartdma_rt500.c fsl_smartdma_rt500.h fsl_spc.c fsl_spc.h fsl_str.c fsl_str.h fsl_usdhc.c fsl_usdhc.h startup_MCXN947_cm33_core0.S system_MCXN947_cm33_core0.c
  group eiq_model
    ../../libraries/components/eiq/tensorflow-lite/model/: get_top_n.cpp get_top_n.h image_load.c image_decode_raw.c image_utils.h image.h model.cpp model.h model_data.h model_data.s model_ops_npu.cpp output_postproc.cpp output_postproc.h yolo_post_processing.cpp yolo_post_processing.h
    ../../libraries/components/eiq/tensorflow-lite/lib/: libtflm.a
    ../../libraries/components/eiq/tensorflow-lite/third_party/neutron/: libNeutronDriver.a libNeutronFirmware.a
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/neutron/: neutron.cpp
  group sdmmc
    ../../libraries/components/sdmmc/host/: fsl_sdmmc_host.c fsl_sdmmc_host.h
    ../../libraries/components/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
    ../../libraries/components/sdmmc/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h fsl_sdmmc_osa.c fsl_sdmmc_osa.h
    ../../libraries/components/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
